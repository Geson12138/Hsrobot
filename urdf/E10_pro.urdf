Commit message: commit_0418_2111

File: urdf/E10_pro.urdf (robot description, URDF)
Before this commit: robot E10-pro_20230227, 8 links, 7 joints
Links:
- removed link elfin_end_link
- added link TCP_grasp
Joints:
- joint elfin_end_joint: child elfin_end_link -> TCP_grasp
